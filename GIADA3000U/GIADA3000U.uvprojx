# Keil uVision project GIADA3000U.uvprojx, settings and files
target GIADA3000U_CHN (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: aGIADA3000U_CHN +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_GIADA3000,CASE_FORHANZI
  c include: ..\STM32F103Driver\USER\inc;..\STM32F103Driver\Libraries\CMSIS;..\STM32F103Driver\Libraries\CMSIS\CoreSupport;..\STM32F103Driver\Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32F103Driver\Utilities\Third_Party\fat_fs\inc;..\STM32F103Driver\Utilities\USB_APP\inc;..\STM32F103Driver\Print;..\ER260_China\EOSCLCD;..\STM32F103Driver\Libraries\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../STM32F103Driver/USER/: asciifonts.c flashb.c fsmc_sram.c interface.c KeyBoard.c monitor.c pwr_ctrl.c spi_m25p80.c stm32f10x_it.c usart.c sdio_sd.c rtc.c led_customer.c lcd_st7565r.c ECR_IAP.c usb_app.c
  group EosCLCD
    ../ER260_China/EOSCLCD/: USBDiskApp.c Agree.c Balance.c Barcode.c Buffer.c Chinaapp.c ChnDIsp.c CHNInput.c CHNMess.c Clerk.c Computer.c Correc.c Currency.c Depart.c Discount.c Drawer.c ePOSCard.c ExtModules.c Firmkey.c Fiscal.c Fixed.c Flowbill.c Format.c General.c Gprs.c Group.c Hardtest.c ICCard.c ICCardBlock.c Initappl.c Kp.c Main.c MEMORY.c Menu.c Modifier.c OFFPrice.c Pb.c Pbbuffer.c Plu.c Pora.c Port.c Print.c Progdump.c Progopt.c Program.c PyCode.c Report2.c Report.c Salper.c Search.c Tax.c Tender.c Timer.c QR_Encode.c EJournal.c
  group Print
    ../STM32F103Driver/Print/: Print_DEF.c Print_Main.c Photo_vuoto.c Photo_abbigl.c Photo_appetito.c Photo_caf.c Photo_caffe.c Photo_carneval.c Photo_cornetto.c Photo_cucina.c Photo_donna.c Photo_eutron.c Photo_fiori.c Photo_gelato.c Photo_jolly.c Photo_MALTA.c Photo_mamma.c Photo_natale.c Photo_panama.c Photo_pane.c Photo_papa.c Photo_pasqua.c Photo_pesce.c Photo_risparmi.c Photo_salumi.c Photo_selfdef.c Photo_sport.c Photo_vacanze.c Photo_valentin.c
  group CMSIS
    ../STM32F103Driver/Libraries/CMSIS/: system_stm32f10x.c startup_stm32f10x_hd.s
    ../STM32F103Driver/Libraries/CMSIS/CoreSupport/: core_cm3.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F103Driver/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USBAPP
    ../STM32F103Driver/Utilities/USB_APP/: usb_pwr.c hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c
  group USB-FS-Device_Driver
    ../STM32F103Driver/Libraries/STM32_USB-FS-Device_Driver/src/: usb_regs.c usb_sil.c usb_core.c usb_init.c usb_int.c usb_mem.c
  group NET_CH395
    ../NET_CH395/: CH395.C
target GIADA3000U_EN (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aGIADA3000U_EN +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_GIADA3000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target GIADA3000U_DEBUG (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aGIADA3000U_DEBUG +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_GIADA3000,CASE_FORHANZI,FOR_DEBUG
  c include: ..\STM32F103Driver\USER\inc;..\STM32F103Driver\Libraries\CMSIS;..\STM32F103Driver\Libraries\CMSIS\CoreSupport;..\STM32F103Driver\Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32F103Driver\Utilities\Third_Party\fat_fs\inc;..\STM32F103Driver\Utilities\USB_APP\inc;..\STM32F103Driver\Print;..\ER260_China\EOSCLCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER520U (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER520UCH_NEW +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER520U,DD_LOCK,CASE_FORHANZI
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER520UEN (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER520UEN_NEW +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER520U,DD_LOCK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER520USP (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER520U4_SP +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER520U,DD_LOCK,CASE_SPANISH
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER520UVN (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER520U_VN +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER520U,DD_LOCK,CASE_VIETNAM,CHAR_6X8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER100CH (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER100CHN +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER100,CASE_FORHANZI,LCD10_DISP,STM32F10X_HD_USBCOMM
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER100EN (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER100EN +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER100,CHAR_6X8,LCD10_DISP,STM32F10X_HD_USBCOMM
  c include: ..\STM32F103Driver\USER\inc;..\STM32F103Driver\Libraries\CMSIS;..\STM32F103Driver\Libraries\CMSIS\CoreSupport;..\STM32F103Driver\Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32F103Driver\Utilities\Third_Party\fat_fs\inc;..\STM32F103Driver\Utilities\USB_APP\inc;..\STM32F103Driver\Print;..\ER260_China\EOSCLCD;..\STM32F103Driver\Utilities\USB_APP\inc;..\STM32F103Driver\Libraries\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER100CH_DEBUG (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER100CHN_DEBUG +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,LCD10_DISP,STM32F10X_HD_USBCOMM,CASE_ER100,FOR_DEBUG,CHAR_6X8,CASE_EJFLASH
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER100VN (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER100VN +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER100,CHAR_6X8,LCD10_DISP,STM32F10X_HD_USBCOMM,CASE_VIETNAM
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER100INDIA_GPRS (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER100EN_INDIA_GPRS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER100,CHAR_6X8,LCD10_DISP,STM32F10X_HD_USBCOMM,CASE_INDONESIA,CASE_INDIA,CASE_GPRS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER220LCHN (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER220L_CHN +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER220,CASE_FORHANZI,STM32F10X_HD_USBCOMM
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER220LEN (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER220L_EN +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER220,STM32F10X_HD_USBCOMM,CHAR_6X8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER220LGPRS_EN (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER220L_GPRS_EN +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER220,STM32F10X_HD_USBCOMM,CASE_GPRS,CASE_INDONESIA,CHAR_6X8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER260LCH (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER260L_CH +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER260,STM32F10X_HD_USBCOMM,CASE_FORHANZI
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER260LEN (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER260L_EN +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER260,STM32F10X_HD_USBCOMM,CHAR_6X8,FOR_DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER520UEN_EJFLASH (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER520UEN_EJFLASH +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER520U,DD_LOCK,CASE_EJFLASH
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER100EN_GPRS (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER100EN_GPRS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER100,CHAR_6X8,LCD10_DISP,STM32F10X_HD_USBCOMM,CASE_GPRS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER520UPERU_SPEJFLASH (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER520UPERUSP_EJFLASH +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER520U,DD_LOCK,CASE_SPANISH,CASE_PERU,CASE_EJFLASH
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER520UPERU_EJFLASH (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER520UPERUEN_EJFLASH +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER520U,DD_LOCK,CASE_PERU,CASE_EJFLASH
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER260LEN_GPRS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER260L_EN_GPRS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER260,STM32F10X_HD_USBCOMM,CHAR_6X8,CASE_GPRS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER520UK_EN_DOTP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER520UK_EN_DOTP +hex
  AfterMake: D:\keil4\ARM\ARMCC\bin\fromelf.exe --bin --output .\obj_STMF103\aER520UK_EN_DOTP.bin .\obj_STMF103\aER520UK_EN_DOTP.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER520U,DD_LOCK,CASE_INNERDOTPRN,ISP_NET
  c include: ..\STM32F103Driver\USER\inc;..\STM32F103Driver\Libraries\CMSIS;..\STM32F103Driver\Libraries\CMSIS\CoreSupport;..\STM32F103Driver\Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32F103Driver\Utilities\Third_Party\fat_fs\inc;..\STM32F103Driver\Utilities\USB_APP\inc;..\STM32F103Driver\Print;..\ER260_China\EOSCLCD;..\STM32F103Driver\Libraries\STM32_USB-FS-Device_Driver\inc;..\NET_CH395
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER260LINDONESIA_GPRS (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER260L_INDONESIA_GPRS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER260,STM32F10X_HD_USBCOMM,CASE_GPRS,CASE_INDONESIA
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER260LINDONESIA_DEBUG (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER260L_INDONESIA_DEBUG +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER260,STM32F10X_HD_USBCOMM,CASE_GPRS,CASE_INDONESIA,FOR_DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ER260LHEBREW (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: aER260L_HEBREW +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,CASE_ER260,STM32F10X_HD_USBCOMM
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 4.3.0
